# Keil uVision project can_fd_msgobjs.uvprojx, settings and files
target can_fd_msgobjs Debug (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC54608J512ET180:M4 NXP
  pack: Keil.LPC54000_DFP.2.6.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: can_fd_msgobjs.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG, CPU_LPC54608, CPU_LPC54608J512ET180=1, USE_FD
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../CMSIS;../board;../drivers;../source;..;../utilities;..\rtos\freertos_9.0.0\template_application\ARM_CM4F;..\rtos\freertos_9.0.0\Source;..\rtos\freertos_9.0.0\Source\portable\RVDS\ARM_CM4F;..\rtos\freertos_9.0.0\Source\portable\MemMang;..\rtos\freertos_9.0.0\Source\include
  asm define: CPU_LPC54114J256_M4, DEBUG,__CC_ARM,KEIL
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x10000
  scatter file: LPC54608J512_flash.scf
  link misc: ../libs/keil_lib_power.lib 
--remove
  group doc
    ../doc/: readme.txt
  group startup
    ../CMSIS/: system_LPC54608.c system_LPC54608.h
    ./: startup_LPC54608.s
  group drivers
    ../drivers/: can.c fsl_clock.c fsl_common.c fsl_emc.c fsl_flexcomm.c fsl_gpio.c fsl_inputmux.c fsl_power.c fsl_reset.c fsl_usart.c can.h fsl_clock.h fsl_emc.h fsl_common.h fsl_flexcomm.h fsl_gpio.h fsl_inputmux.h fsl_inputmux_connections.h fsl_iocon.h fsl_power.h fsl_reset.h fsl_usart.h
  group source
    ../source/: can_fd_msgobjs.c
    ../rtos/freertos_9.0.0/template_application/ARM_CM4F/: FreeRTOSConfig.h
  group board
    ../board/: board.h clock_config.h pin_mux.h board.c clock_config.c pin_mux.c
  group utilities
    ../utilities/: fsl_debug_console.c fsl_debug_console.h obd_can.c obd_usart.c obd_control.c
  group FreeRTOS
    ../rtos/freertos_9.0.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_4.c
  group FreeRTOS_Portable
    ../rtos/freertos_9.0.0/Source/portable/RVDS/ARM_CM4F/: fsl_tickless_rtc.c fsl_tickless_systick.c port.c
target can_fd_msgobjs Release (ARM-ADS)
  device: LPC54608J512ET180:M4 NXP
  pack: Keil.LPC54000_DFP.2.6.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: can_fd_msgobjs.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG, CPU_LPC54618, CPU_LPC54618J512BD208=1
  c misc: as above
  c include: ../../../../../../CMSIS/Include;../../../../../../devices;../../../../../../devices/LPC54618;../../../..;..;../../../../../../devices/LPC54618/drivers;../../../../../../devices/LPC54618/utilities
  asm define: CPU_LPC54114J256_M4, NDEBUG,__CC_ARM,KEIL
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC54608J512_flash.scf
  link misc: ../../../../../../devices/LPC54618/arm/keil_lib_power.lib 
--remove
